# Keil uVision project FreeRTOS.uvprojx, settings and files
target rtos (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\usr_libs\Drivers\inc;.\usr_libs\CMSIS;.\usr_src;.\usr_libs\StartUp;.\usr_rtos\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./usr_libs/StartUp/: core_cm3.c startup_stm32f10x_md.s
  group cmsis
    ./usr_libs/CMSIS/: system_stm32f10x.c
  group drivers
    ./usr_libs/Drivers/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group usersrc
    ./usr_src/: main.c stm32f10x_it.c user_tasks.c init_periph.c timers2and3.c usart3_debug.c delay_us.c adc_inject.c adc_regular.c adc_irq.c
  group rtos
    ./usr_rtos/: croutine.c event_groups.c heap_4.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
